PACKAGECONFIG_append = " libav lib4vl ffmpeg"

