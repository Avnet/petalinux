FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://hciattach-reset-delay-bluez-5.41.patch"
