SRC_URI += "file://user_2018-06-26-17-14-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
