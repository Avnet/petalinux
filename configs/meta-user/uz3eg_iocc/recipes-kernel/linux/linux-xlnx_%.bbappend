SRC_URI += "file://bsp.cfg \
            file://user_2019-10-31-20-33-00.cfg \
            "
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
