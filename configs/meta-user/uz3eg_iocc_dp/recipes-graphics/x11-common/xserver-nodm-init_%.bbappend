INITSCRIPT_PARAMS = ""
