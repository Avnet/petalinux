FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-fix-login-disabled-user.patch"
