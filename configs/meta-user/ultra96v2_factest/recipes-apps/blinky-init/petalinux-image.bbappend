IMAGE_INSTALL_append = " blinky-init"
