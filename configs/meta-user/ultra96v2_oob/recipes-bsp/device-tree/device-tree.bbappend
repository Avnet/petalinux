SRC_URI_append ="\
    file://system-user.dtsi \
    file://openamp.dtsi \
"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
