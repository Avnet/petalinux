IMAGE_INSTALL_append = " uz7ev-evcc-factest-init"
