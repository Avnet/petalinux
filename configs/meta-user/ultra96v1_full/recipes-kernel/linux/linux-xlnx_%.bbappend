SRC_URI += "file://user_ULTRA96V1.cfg \
            file://user_2019-04-26-13-08-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
