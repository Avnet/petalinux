SRC_URI += "file://user_2018-01-11-14-47-00.cfg \
            file://user_2018-01-11-14-52-00.cfg \
            file://user_2018-01-11-15-39-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

