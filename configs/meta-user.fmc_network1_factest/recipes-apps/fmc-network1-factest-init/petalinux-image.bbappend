IMAGE_INSTALL_append = " fmc-network1-factest-init"
