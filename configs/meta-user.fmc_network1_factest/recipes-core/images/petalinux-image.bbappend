IMAGE_INSTALL_append = " iperf3"

IMAGE_INSTALL_append = " eeprom-test"
IMAGE_INSTALL_append = " fmc-network1-factest"
IMAGE_INSTALL_append = " fmc-network1-factest-init"
IMAGE_INSTALL_append = " fmc-network1-factest-launcher"
